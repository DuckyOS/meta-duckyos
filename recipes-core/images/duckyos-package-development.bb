require duckyos-package.inc

IMAGE_NAME .= "-development"