require duckyos-package.inc